# Copyright (c) 2019 LG Electronics, Inc.

inherit pypi setuptools3
require python-typing.inc
